Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: ddf596e7-bf59-40d5-b28f-3cb9ff66dd7e, NumberOfSaves: 0]
File name: RSen_55_ME_FB_LOD200 - fan coils_jaga_bamw0.06309022-bt-20 - wall mounted - 2 pipe_jaga_briza 22_lxhxd 900x630x230 mm.ifc
Time: 2025-01-21T09:25:31
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - IFC 22.7.0.0 - Default UI

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_AirSideSystemInformation - sets with these values: 2
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 27
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Other(Type) - Category: Levels; Family Name: Level
Name | LongName = Pset_AirSideSystemInformation, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcBuildingElementProxy: RSen_55_GM_FB_logo - SH_jaga:standard, RSen_55_GM_FB_logo - SH_jaga:standard:220038
In: Level 1
Type - Material: RSen_x_rgb 000 000 000 T00 black_gen
Type - Constraints - Default Elevation: 1219.2 mm
Type - Materials and Finishes - RSen_C_material: RSen_x_rgb 000 000 000 T00 black_gen
Type - Identity Data - Type Name: standard
Type - Other - Category: Generic Models; Family Name: RSen_55_GM_FB_logo - SH_jaga
Pset_BuildingElementProxyCommon - Reference: standard; sets with these values: 2
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no
Phasing - Phase Created: New Construction
Dimensions - Area: 0.00950156 m2; Volume: 0.0000163375 m3
Other - Family: RSen_55_GM_FB_logo - SH_jaga; Family and Type: RSen_55_GM_FB_logo - SH_jaga: standard; Type: standard; Type Id: 219438

# IfcEnergyConversionDevice: RSen_55_ME_FB_LOD200 - fan coils_jaga:bamw0.06309022/bt/20 - wall mounted - 2 pipe_jaga_briza 22_lxhxd 900x630x230 mm, RSen_55_ME_FB_LOD200 - fan coils_jaga:bamw0.06309022/bt/20 - wall mounted - 2 pipe_jaga_briza 22_lxhxd 900x630x230 mm:220037
In: Level 1
Type - PredefinedType: CONVECTOR; Classification: 56.10.60.11 Uniformat (Uniformat); Material: RSen_x_rgb 241 236 225 T00 white 101_gen
Type - Model Properties - RSen_C_volume: 0 m3; RSen_S_weight_net: 0 kg; TBQ_I Offset from base level_max: 0 mm; TBQ_I Offset from base level_min: 100 mm; TBQ_I Volume per meter: 0 m3; TBQ_I Weight per meter: 0 kg
Type - Energy Analysis - TBQ_I Default Emission_Cooling: 1891 W; TBQ_I Default Emission_Heating: 6060 W; TBQ_I N-Value: 0
Type - Constraints - Default Elevation: 100 mm
Type - Materials and Finishes - RSen_C_material: RSen_x_rgb 241 236 225 T00 white 101_gen; TBQ_I Colour: -; TBQ_I Colour chart: -
Type - Construction - TBQen_C_SOg_ME_01: RSen_00_ME_FB_none_gen_thorbiq : none_gen; TBQen_C_SOg_ME_02: RSen_00_ME_FB_none_gen_thorbiq : none_gen
Type - Dimensions - RSen_C_depth: 230 mm; RSen_C_height: 630 mm; RSen_C_length: 900 mm
Type - Identity Data - Assembly Code: 56.10.60.11; Description: BAMW WALL L090 BT LEFT 2P; Manufacturer: Jaga; Model: Briza 22; OmniClass Number: 23.75.70.17.27; OmniClass Title: Fan Coil Units; RSen_C_code_article: BAMW0.06309022/BT/20; RSen_C_code_ETIM: -; RSen_C_code_ETIM_URL: https://prod.etim-international.com/Class/Details?classId=EC010152&classVersion=4; RSen_C_code_gtin: -; RSen_C_content_creator: www.thorbiq.com; RSen_C_content_date_changed: 15/12/2024; RSen_C_content_date_issue: 15/12/2024; RSen_C_content_provider: Jaga; RSen_C_content_version: 1.0.0; RSen_C_description: BAMW WALL L090 BT LEFT 2P; RSen_C_model: Briza 22; RSen_C_revit_version: 2022; RSen_C_type: 2 pipe; RSen_C_type_comments: Wall mounted; TBQ_I BaseKeynote: 56.10.60.11; TBQen_C_code_product: -; TBQen_C_IFC_version: 2x3; TBQen_C_license: Creative Commons Attribution NoDerivs (CC-ND); TBQen_C_license_info: https://tldrlegal.com/license/creative-commons-attribution-noderivs-(cc-nd)#summary; Type Comments: Wall mounted; Type Name: bamw0.06309022/bt/20 - wall mounted - 2 pipe_jaga_briza 22_lxhxd 900x630x230 mm; URL: www.jaga.com
Type - Other - Category: Mechanical Equipment; Family Name: RSen_55_ME_FB_LOD200 - fan coils_jaga
Type - Pset_ManufacturerTypeInformation - Manufacturer: Jaga
Pset_DistributionFlowElementCommon - Reference: bamw0.06309022/bt/20 - wall mounted - 2 pipe_jaga_briza 22_lxhxd 900x630x230 mm; sets with these values: 2
Energy Analysis - RSen_M_output_heating: 6060 W; TBQen_M_temperature_heating: 20 C; TBQen_M_temperature_heating_return: 65 C; TBQen_M_temperature_heating_supply: 75 C
Text - RSen_C_content_manual: https://thorbiq.freshdesk.com/support/home
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level 1; Schedule Level: Level 1
Phasing - Phase Created: New Construction
Graphics - TBQen_C_clearance_zone: no
Construction - TBQen_C_alignment: Center; TBQen_C_alignment_index: 0; TBQen_C_GOg: yes; TBQen_C_logo: yes; TBQen_C_offset_from_base_level: 100 mm; TBQen_C_SOg: no
Dimensions - Area: 9.20069 m2; Volume: 1.3041 m3
Identity Data - Mark: 6
Other - Family: RSen_55_ME_FB_LOD200 - fan coils_jaga; Family and Type: RSen_55_ME_FB_LOD200 - fan coils_jaga: bamw0.06309022/bt/20 - wall mounted - 2 pipe_jaga_briza 22_lxhxd 900x630x230 mm; Type: bamw0.06309022/bt/20 - wall mounted - 2 pipe_jaga_briza 22_lxhxd 900x630x230 mm; Type Id: 219700
